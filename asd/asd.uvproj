# Keil uVision project asd.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: asd
  c flags: Optim=1
  c include: ..\asd;..\CMSIS\DeviceSupport\ST\STM32F10x;..\CMSIS;..\CMSIS\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: startup_stm32f10x_ld_vl.s main.c
    ../CMSIS/CoreSupport/: core_cm3.c
    ../CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
