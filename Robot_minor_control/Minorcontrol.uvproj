# Keil uVision project Minorcontrol.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Minorcontrol +hex
  c flags: Optim=1
  c include: ..\CMSIS\CoreSupport;..\Robot_minor_control;..\CMSIS\DeviceSupport\ST\STM32F10x;..\CMSIS;..\ISL90810;..\General;..\Macro
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group startup
    ./: startup_stm32f10x_ld_vl.s
  group CMISIS
    ../CMSIS/CoreSupport/: core_cm3.c
    ../CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group source
    ./: main.h main.c
    ../ISL90810/: ISL90810.c
    ../Macro/: mcu_gpio.h
