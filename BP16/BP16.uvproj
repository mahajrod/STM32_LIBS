# Keil uVision project BP16.uvproj, settings and files
target BP16 (ARM-ADS)
  device: STM32F100C4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BP16
  c flags: Optim=1
  c include: ..\File_types;..\General;..\Macro
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ./: startup_stm32f10x_ld_vl.s
  group CMSIS
    ./CMSIS/CoreSupport/: core_cm3.c
    ./CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group headers
    ./: main.h
    ../General/: general_pin_definitions.h
  group source
    ./: main.c
