# Keil uVision project test.uvproj, settings and files
target Pinboard_tst (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test +hex
  c flags: Optim=1
  c include: ..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport\ST\STM32F10x;..\test;..\LCD16x2;..\SDcard;..\FreeRTOS;..\FreeRTOS\include;..\MPL115A1;..\ULN2003;..\Bipolar_St_Motor;..\___SHT21;..\Macro;..\Nokia1616;..\I2C_peripherials;..\RF2400P;..\FatFs\src;..\File_types
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./: startup_stm32f10x_md.s
  group CMSIS
    ../CMSIS/CoreSupport/: core_cm3.c
    ../CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group source
    ../File_types/: image_files.c
    ./: main.c
    ../Nokia1616/: Nokia1616.c Nokia1616_GUI.c
    ../FatFs/src/: diskio.c ff.c
  group headers
    ../Nokia1616/: Nokia1616_GUI.h Nokia1616.h font.h
    ./: main.h
    ../Macro/: mcu_gpio.h mcu_rcc.h
    ../FatFs/src/: integer.h diskio.h ff.h ffconf.h
    ../File_types/: file_types_conf.h image_files.h
  group SDcard
    ../SDcard/: SDcard.c SDcard.h
  group FreeRTOS
    ../FreeRTOS/: tasks.c heap_2.c port.c timers.c queue.c croutine.c list.c
  group FreeRTOS_headers
    ../FreeRTOS/include/: portable.h semphr.h task.h FreeRTOS.h
    ../FreeRTOS/: FreeRTOSConfig.h portmacro.h
